## configs/callbacks/sample.yaml
```yaml
sample:
  _target_: src.callbacks.visualization.SampleImagesCallback
  batch_size: 64
  every_n_epochs: 1
```
